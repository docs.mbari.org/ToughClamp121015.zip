ISO-10303-21;
HEADER;
FILE_DESCRIPTION(('STEP AP214'),'2;1');
FILE_NAME('part.step','',(''),(''),'','','');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
ENDSEC;
DATA;
#1=APPLICATION_CONTEXT('core data for automotive mechanical design processes');
#2=APPLICATION_PROTOCOL_DEFINITION('international standard','automotive_design',2000,#1);
#3=PRODUCT_CONTEXT('',#1,'mechanical');
#4=PRODUCT('Part','Part','',(#3));
#5=PRODUCT_RELATED_PRODUCT_CATEGORY('part','',(#4));
#6=PRODUCT_DEFINITION_FORMATION('','',#4);
#7=PRODUCT_DEFINITION_CONTEXT('part definition',#1,'design');
#8=PRODUCT_DEFINITION('design','',#6,#7);
#9=PRODUCT_DEFINITION_SHAPE('','',#8);
#10=(LENGTH_UNIT() NAMED_UNIT(*) SI_UNIT(.MILLI.,.METRE.));
#11=(NAMED_UNIT(*) PLANE_ANGLE_UNIT() SI_UNIT($,.RADIAN.));
#12=(NAMED_UNIT(*) SI_UNIT($,.STERADIAN.) SOLID_ANGLE_UNIT());
#13=UNCERTAINTY_MEASURE_WITH_UNIT(LENGTH_MEASURE(1.E-05),#10,'distance_accuracy_value','');
#14=(GEOMETRIC_REPRESENTATION_CONTEXT(3) GLOBAL_UNCERTAINTY_ASSIGNED_CONTEXT((#13)) GLOBAL_UNIT_ASSIGNED_CONTEXT((#10,
#11,#12)) REPRESENTATION_CONTEXT('',''));
#15=CARTESIAN_POINT('',(0.,0.,0.));
#16=DIRECTION('',(0.,0.,1.));
#17=DIRECTION('',(1.,0.,0.));
#18=AXIS2_PLACEMENT_3D('',#15,#16,#17);
#19=CARTESIAN_POINT('',(-0.60000000000042,0.,-2.22044604925031E-13));
#20=DIRECTION('',(-1.00000000000003,0.,0.));
#21=DIRECTION('',(0.,0.,1.00000000000001));
#22=AXIS2_PLACEMENT_3D('',#19,#20,#21);
#23=TOROIDAL_SURFACE('',#22,1.45,0.1);
#24=CARTESIAN_POINT('',(-0.60000000000042,0.,-2.22044604925031E-13));
#25=DIRECTION('',(-1.00000000000003,0.,0.));
#26=DIRECTION('',(0.,0.,1.00000000000001));
#27=AXIS2_PLACEMENT_3D('',#24,#25,#26);
#28=CIRCLE('',#27,1.35);
#29=CARTESIAN_POINT('',(-0.600000000000281,0.315000000000086,1.31273569312337));
#30=VERTEX_POINT('',#29);
#31=CARTESIAN_POINT('',(-0.600000000000402,-0.314999999999965,1.31273569312344));
#32=VERTEX_POINT('',#31);
#33=EDGE_CURVE('E124',#30,#32,#28,.T.);
#34=ORIENTED_EDGE('',*,*,#33,.F.);
#35=CARTESIAN_POINT('',(-0.644971193462948,0.315000000000015,1.32371909110286));
#36=CARTESIAN_POINT('',(-0.650010058531001,0.314999999999967,1.32632732083888));
#37=CARTESIAN_POINT('',(-0.654828426294342,0.315000000000076,1.32937191075762));
#38=CARTESIAN_POINT('',(-0.663885392286133,0.315000000000163,1.33623471928736));
#39=CARTESIAN_POINT('',(-0.668123109041374,0.315000000000142,1.34005409274874));
#40=CARTESIAN_POINT('',(-0.675895604651959,0.315000000000127,1.34833972508503));
#41=CARTESIAN_POINT('',(-0.679431494345622,0.315000000000134,1.35280494204696));
#42=CARTESIAN_POINT('',(-0.685719019400222,0.315000000000105,1.36225446296608));
#43=CARTESIAN_POINT('',(-0.688470848547421,0.315000000000069,1.36723863824241));
#44=CARTESIAN_POINT('',(-0.693170577433031,0.315000000000078,1.37768789684115));
#45=CARTESIAN_POINT('',(-0.69510205352096,0.315000000000125,1.38316036787858));
#46=CARTESIAN_POINT('',(-0.698036470669394,0.315000000000115,1.39434924391713));
#47=CARTESIAN_POINT('',(-0.699039271167916,0.315000000000058,1.40006568570813));
#48=CARTESIAN_POINT('',(-0.700100009411781,0.315000000000072,1.41168448425153));
#49=CARTESIAN_POINT('',(-0.700141507810849,0.315000000000146,1.41758834871237));
#50=CARTESIAN_POINT('',(-0.699234817454044,0.315000000000094,1.42931987043458));
#51=CARTESIAN_POINT('',(-0.698286596094074,0.314999999999969,1.435147525179));
#52=CARTESIAN_POINT('',(-0.695419580629259,0.314999999999968,1.44656971853457));
#53=CARTESIAN_POINT('',(-0.693499183542346,0.315000000000092,1.45216385556391));
#54=CARTESIAN_POINT('',(-0.688734249595382,0.315000000000148,1.46294399230233));
#55=CARTESIAN_POINT('',(-0.685889765456332,0.315000000000079,1.46813001527417));
#56=CARTESIAN_POINT('',(-0.679394138106317,0.315000000000052,1.47787151712418));
#57=CARTESIAN_POINT('',(-0.675754079162315,0.315000000000093,1.48243438236793));
#58=CARTESIAN_POINT('',(-0.667744477932957,0.315000000000147,1.49086759516335));
#59=CARTESIAN_POINT('',(-0.663375018843696,0.31500000000016,1.49473802159108));
#60=CARTESIAN_POINT('',(-0.654129699124317,0.315000000000164,1.5015885769807));
#61=CARTESIAN_POINT('',(-0.649266526531169,0.315000000000155,1.5045858286634));
#62=CARTESIAN_POINT('',(-0.639098131156996,0.315000000000084,1.50970183608992));
#63=CARTESIAN_POINT('',(-0.633792962595015,0.315000000000021,1.51182069939446));
#64=CARTESIAN_POINT('',(-0.623005979471424,0.315000000000026,1.51507739409551));
#65=CARTESIAN_POINT('',(-0.617529846587752,0.315000000000092,1.51623406003711));
#66=CARTESIAN_POINT('',(-0.606460784558231,0.315000000000148,1.51759993853068));
#67=CARTESIAN_POINT('',(-0.600867864703478,0.315000000000138,1.5178092261659));
#68=CARTESIAN_POINT('',(-0.589791031069575,0.315000000000107,1.51727675243754));
#69=CARTESIAN_POINT('',(-0.584306599242517,0.315000000000085,1.5165456871122));
#70=CARTESIAN_POINT('',(-0.573538243780035,0.315000000000154,1.5141741754776));
#71=CARTESIAN_POINT('',(-0.568254317533364,0.315000000000245,1.51253374101568));
#72=CARTESIAN_POINT('',(-0.55802765730458,0.315000000000242,1.50839201015674));
#73=CARTESIAN_POINT('',(-0.553085380592134,0.315000000000148,1.50588958585414));
#74=CARTESIAN_POINT('',(-0.543683801583778,0.315000000000091,1.50010084312694));
#75=CARTESIAN_POINT('',(-0.539224524383283,0.315000000000128,1.49681448399947));
#76=CARTESIAN_POINT('',(-0.530850655205001,0.315000000000152,1.48950701612472));
#77=CARTESIAN_POINT('',(-0.526944036816378,0.315000000000139,1.48547677468585));
#78=CARTESIAN_POINT('',(-0.519846494862988,0.315000000000099,1.47682916479839));
#79=CARTESIAN_POINT('',(-0.516655640984405,0.315000000000072,1.4722117392506));
#80=CARTESIAN_POINT('',(-0.511010216301803,0.315000000000075,1.46242009090607));
#81=CARTESIAN_POINT('',(-0.508572075390722,0.315000000000107,1.45723639630142));
#82=CARTESIAN_POINT('',(-0.504580870771417,0.315000000000132,1.4465388530669));
#83=CARTESIAN_POINT('',(-0.503027906682442,0.315000000000126,1.44102496735392));
#84=CARTESIAN_POINT('',(-0.500820192200704,0.315000000000119,1.42970323761815));
#85=CARTESIAN_POINT('',(-0.500184404006328,0.31500000000012,1.42389169205323));
#86=CARTESIAN_POINT('',(-0.499884898489538,0.315000000000119,1.41224344172874));
#87=CARTESIAN_POINT('',(-0.500221264005,0.315000000000117,1.40640673486747));
#88=CARTESIAN_POINT('',(-0.501866392497266,0.315000000000138,1.39480068307566));
#89=CARTESIAN_POINT('',(-0.503186685832558,0.31500000000016,1.38903296767045));
#90=CARTESIAN_POINT('',(-0.506779511395285,0.315000000000078,1.37780174059752));
#91=CARTESIAN_POINT('',(-0.509052059542944,0.314999999999973,1.37233823401742));
#92=CARTESIAN_POINT('',(-0.514483328893768,0.314999999999994,1.36189161862727));
#93=CARTESIAN_POINT('',(-0.517639332504195,0.315000000000118,1.35690709859548));
#94=CARTESIAN_POINT('',(-0.52475820976283,0.31500000000012,1.34755152247136));
#95=CARTESIAN_POINT('',(-0.528721013658447,0.314999999999997,1.34318041340123));
#96=CARTESIAN_POINT('',(-0.537264852044036,0.314999999999995,1.33526598682599));
#97=CARTESIAN_POINT('',(-0.541833018793867,0.315000000000111,1.3317087866428));
#98=CARTESIAN_POINT('',(-0.551514919448295,0.315000000000127,1.32543666262596));
#99=CARTESIAN_POINT('',(-0.556628543633327,0.315000000000027,1.32272156982892));
#100=CARTESIAN_POINT('',(-0.567110548462559,0.315000000000003,1.31828629427331));
#101=CARTESIAN_POINT('',(-0.572468577048787,0.315000000000076,1.31654163694069));
#102=CARTESIAN_POINT('',(-0.583406079080944,0.315000000000163,1.3139977191372));
#103=CARTESIAN_POINT('',(-0.588985579897433,0.315000000000177,1.31319857589564));
#104=CARTESIAN_POINT('',(-0.600084317450359,0.315000000000182,1.31258015419117));
#105=CARTESIAN_POINT('',(-0.6056024880955,0.315000000000173,1.31274136977419));
#106=CARTESIAN_POINT('',(-0.616527350630029,0.315000000000066,1.31399295613576));
#107=CARTESIAN_POINT('',(-0.621934179365467,0.31499999999997,1.31508210677447));
#108=CARTESIAN_POINT('',(-0.630275059812531,0.315000000000044,1.31750648755643));
#109=CARTESIAN_POINT('',(-0.633297577937375,0.31500000000012,1.31854830065956));
#110=CARTESIAN_POINT('',(-0.639227093933215,0.315000000000119,1.32092033268628));
#111=CARTESIAN_POINT('',(-0.642134094473063,0.315000000000042,1.32225054494227));
#112=CARTESIAN_POINT('',(-0.644971193462948,0.315000000000015,1.32371909110286));
#113=B_SPLINE_CURVE_WITH_KNOTS('',3,(#35,#36,#37,#38,#39,#40,#41,#42,#43,#44,#45,#46,#47,#48,
#49,#50,#51,#52,#53,#54,#55,#56,#57,#58,#59,#60,#61,#62,#63,#64,#65,#66,#67,#68,#69,#70,#71,#72,
#73,#74,#75,#76,#77,#78,#79,#80,#81,#82,#83,#84,#85,#86,#87,#88,#89,#90,#91,#92,#93,#94,#95,#96,
#97,#98,#99,#100,#101,#102,#103,#104,#105,#106,#107,#108,#109,#110,#111,#112),.UNSPECIFIED.,.T.,
.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.0170096277632855,0.0340447979509988,0.0510527863374496,0.0680565674222536,0.0853863307541381,
0.102718716646598,0.120347290989283,0.137976446084133,0.15563476433548,0.173292075321578,
0.190717496668784,0.208140931811722,0.225195279482804,0.242247538191806,0.25895758236809,
0.275666302188197,0.292186638844972,0.308706760278396,0.325248580768624,0.341791260317508,
0.358552472039635,0.375315314910593,0.392421701981107,0.409530013852477,0.426987199308171,
0.444445872346284,0.462112420566797,0.479779264156392,0.497392349019497,0.515003911774832,
0.532287952841513,0.549568523730927,0.566390831897445,0.583215225554913,0.599699078106745,
0.616161289467834,0.62573866705052,0.635315823234262),.UNSPECIFIED.);
#114=CARTESIAN_POINT('',(-0.700000000000256,0.315000000000109,1.41537097610477));
#115=VERTEX_POINT('',#114);
#116=EDGE_CURVE('E48',#30,#115,#113,.T.);
#117=ORIENTED_EDGE('',*,*,#116,.T.);
#118=CARTESIAN_POINT('',(-0.700000000000464,1.04083408558608E-13,-3.60822483003176E-13));
#119=DIRECTION('',(-1.00000000000003,0.,0.));
#120=DIRECTION('',(0.,0.,1.00000000000001));
#121=AXIS2_PLACEMENT_3D('',#118,#119,#120);
#122=CIRCLE('',#121,1.45);
#123=CARTESIAN_POINT('',(-0.7000000000001,-0.315000000000003,1.41537097610478));
#124=VERTEX_POINT('',#123);
#125=EDGE_CURVE('E136',#115,#124,#122,.T.);
#126=ORIENTED_EDGE('',*,*,#125,.T.);
#127=CARTESIAN_POINT('',(-0.64497119346275,-0.314999999999992,1.3237190911025));
#128=CARTESIAN_POINT('',(-0.640091733730177,-0.315000000000036,1.32119394292424));
#129=CARTESIAN_POINT('',(-0.634998552290992,-0.314999999999854,1.31907421036948));
#130=CARTESIAN_POINT('',(-0.624525327255292,-0.314999999999859,1.31571662868087));
#131=CARTESIAN_POINT('',(-0.619145020213387,-0.315000000000047,1.314479604945));
#132=CARTESIAN_POINT('',(-0.608252100127179,-0.315000000000062,1.31293065478855));
#133=CARTESIAN_POINT('',(-0.602739484265209,-0.31499999999989,1.31261874808706));
#134=CARTESIAN_POINT('',(-0.591742086767547,-0.314999999999824,1.31293094680859));
#135=CARTESIAN_POINT('',(-0.586257299616717,-0.31499999999993,1.31355485886898));
#136=CARTESIAN_POINT('',(-0.57550047286186,-0.31499999999993,1.3157113433436));
#137=CARTESIAN_POINT('',(-0.570227447165121,-0.314999999999824,1.31723900752965));
#138=CARTESIAN_POINT('',(-0.560008742901896,-0.31499999999989,1.32114923206465));
#139=CARTESIAN_POINT('',(-0.555063084198727,-0.315000000000061,1.3235318442322));
#140=CARTESIAN_POINT('',(-0.545582813679385,-0.315000000000076,1.32910564794022));
#141=CARTESIAN_POINT('',(-0.541052913644611,-0.314999999999917,1.33230484586715));
#142=CARTESIAN_POINT('',(-0.532578761553763,-0.314999999999797,1.33940208524469));
#143=CARTESIAN_POINT('',(-0.528634572494611,-0.314999999999836,1.34330020176903));
#144=CARTESIAN_POINT('',(-0.521344034129301,-0.314999999999857,1.35178163004008));
#145=CARTESIAN_POINT('',(-0.518013927956363,-0.314999999999837,1.35637890121283));
#146=CARTESIAN_POINT('',(-0.512150454081324,-0.314999999999877,1.36605607815448));
#147=CARTESIAN_POINT('',(-0.50961719105728,-0.314999999999937,1.37113604721941));
#148=CARTESIAN_POINT('',(-0.505354641309099,-0.314999999999923,1.38177149867468));
#149=CARTESIAN_POINT('',(-0.503647140536967,-0.314999999999844,1.38733571842479));
#150=CARTESIAN_POINT('',(-0.501174595906914,-0.31499999999987,1.39866989498819));
#151=CARTESIAN_POINT('',(-0.500409646880909,-0.314999999999973,1.40443987244307));
#152=CARTESIAN_POINT('',(-0.499837586063724,-0.314999999999984,1.41611617047465));
#153=CARTESIAN_POINT('',(-0.500045330937427,-0.314999999999887,1.42202322547411));
#154=CARTESIAN_POINT('',(-0.50144965276627,-0.314999999999827,1.43371890466776));
#155=CARTESIAN_POINT('',(-0.502646252010033,-0.314999999999864,1.43950752618946));
#156=CARTESIAN_POINT('',(-0.505999703972118,-0.314999999999864,1.45079759514843));
#157=CARTESIAN_POINT('',(-0.508156178888268,-0.314999999999827,1.45629915462099));
#158=CARTESIAN_POINT('',(-0.513375473786427,-0.314999999999886,1.46685447314246));
#159=CARTESIAN_POINT('',(-0.516438235473864,-0.314999999999982,1.47190826096598));
#160=CARTESIAN_POINT('',(-0.523338061111519,-0.314999999999954,1.48134337143214));
#161=CARTESIAN_POINT('',(-0.527163160107193,-0.314999999999833,1.48573343922656));
#162=CARTESIAN_POINT('',(-0.535510683191512,-0.314999999999881,1.49379149610152));
#163=CARTESIAN_POINT('',(-0.540033023927425,-0.31500000000005,1.49745957137448));
#164=CARTESIAN_POINT('',(-0.549542103932518,-0.315000000000046,1.5038851741536));
#165=CARTESIAN_POINT('',(-0.554516735257215,-0.314999999999879,1.50666062046627));
#166=CARTESIAN_POINT('',(-0.56486808182896,-0.314999999999834,1.51131790593102));
#167=CARTESIAN_POINT('',(-0.570244749217193,-0.314999999999955,1.51319985125103));
#168=CARTESIAN_POINT('',(-0.581135586925265,-0.31499999999996,1.51598126477739));
#169=CARTESIAN_POINT('',(-0.586645093987218,-0.314999999999849,1.51689901143795));
#170=CARTESIAN_POINT('',(-0.597739805315516,-0.314999999999864,1.51778634445995));
#171=CARTESIAN_POINT('',(-0.603325004109597,-0.314999999999991,1.51775599900368));
#172=CARTESIAN_POINT('',(-0.614354607505639,-0.314999999999973,1.51675324335768));
#173=CARTESIAN_POINT('',(-0.619799855676562,-0.31499999999983,1.51579007399161));
#174=CARTESIAN_POINT('',(-0.630452007627806,-0.314999999999883,1.51296573131855));
#175=CARTESIAN_POINT('',(-0.635658912332575,-0.31500000000008,1.51110456149492));
#176=CARTESIAN_POINT('',(-0.645704916469974,-0.315000000000085,1.50653525277991));
#177=CARTESIAN_POINT('',(-0.650542890189918,-0.314999999999894,1.5038246412322));
#178=CARTESIAN_POINT('',(-0.659703581222049,-0.314999999999819,1.49764063049679));
#179=CARTESIAN_POINT('',(-0.664026268681972,-0.314999999999936,1.49416718714878));
#180=CARTESIAN_POINT('',(-0.672102227832899,-0.314999999999952,1.48650445037804));
#181=CARTESIAN_POINT('',(-0.675846368643459,-0.314999999999847,1.48230553797739));
#182=CARTESIAN_POINT('',(-0.682593840064309,-0.314999999999865,1.47334980855407));
#183=CARTESIAN_POINT('',(-0.685597094264223,-0.314999999999989,1.46859293406129));
#184=CARTESIAN_POINT('',(-0.690844467567112,-0.315000000000003,1.45855015969779));
#185=CARTESIAN_POINT('',(-0.693071384541861,-0.314999999999887,1.45325527196206));
#186=CARTESIAN_POINT('',(-0.696624192917621,-0.314999999999825,1.44237140522318));
#187=CARTESIAN_POINT('',(-0.697949982747919,-0.314999999999878,1.43678239314423));
#188=CARTESIAN_POINT('',(-0.699687649061869,-0.314999999999885,1.42535059193363));
#189=CARTESIAN_POINT('',(-0.700080912694626,-0.314999999999837,1.41950496921312));
#190=CARTESIAN_POINT('',(-0.699891430690704,-0.314999999999875,1.40782957159747));
#191=CARTESIAN_POINT('',(-0.69930864345785,-0.31499999999996,1.40199979738836));
#192=CARTESIAN_POINT('',(-0.697171605637446,-0.314999999999962,1.39045920405683));
#193=CARTESIAN_POINT('',(-0.695607510997407,-0.314999999999876,1.38475020375487));
#194=CARTESIAN_POINT('',(-0.691537884534224,-0.314999999999836,1.37367605779154));
#195=CARTESIAN_POINT('',(-0.689032119324467,-0.314999999999883,1.36831099775959));
#196=CARTESIAN_POINT('',(-0.683157678324627,-0.314999999999845,1.35810950321959));
#197=CARTESIAN_POINT('',(-0.679793069098299,-0.314999999999762,1.35327072669063));
#198=CARTESIAN_POINT('',(-0.672285957357661,-0.31499999999995,1.34424619013142));
#199=CARTESIAN_POINT('',(-0.668144479158578,-0.31500000000022,1.34005958335954));
#200=CARTESIAN_POINT('',(-0.660805152101115,-0.315000000000085,1.3338321588942));
#201=CARTESIAN_POINT('',(-0.657800576475547,-0.314999999999887,1.33155984917787));
#202=CARTESIAN_POINT('',(-0.651554476532943,-0.314999999999826,1.32736800944864));
#203=CARTESIAN_POINT('',(-0.648312956783731,-0.314999999999962,1.32544847263747));
#204=CARTESIAN_POINT('',(-0.64497119346275,-0.314999999999992,1.3237190911025));
#205=B_SPLINE_CURVE_WITH_KNOTS('',3,(#127,#128,#129,#130,#131,#132,#133,#134,#135,#136,#137,
#138,#139,#140,#141,#142,#143,#144,#145,#146,#147,#148,#149,#150,#151,#152,#153,#154,#155,#156,
#157,#158,#159,#160,#161,#162,#163,#164,#165,#166,#167,#168,#169,#170,#171,#172,#173,#174,#175,
#176,#177,#178,#179,#180,#181,#182,#183,#184,#185,#186,#187,#188,#189,#190,#191,#192,#193,#194,
#195,#196,#197,#198,#199,#200,#201,#202,#203,#204),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.0164689397156334,
0.0329532589985091,0.0494379296456965,0.065919194633218,0.0823117620263095,0.0987053231447345,
0.115266244494976,0.131828945788954,0.148781202973988,0.165735686179255,0.183115912009003,
0.200497886353431,0.218146206802907,0.235794925053627,0.253436702992827,0.271077346416515,
0.288460287700415,0.305841152525463,0.32284746051107,0.339851747260122,0.356527521360782,
0.373202096221746,0.389713159866744,0.406224159465738,0.422783674830332,0.439344149077513,
0.456143927773729,0.472945438369603,0.490098563005831,0.507253620739182,0.524748306083297,
0.542243737014063,0.559917544024787,0.57759573425967,0.595191723929107,0.612764674012694,
0.624043865236416,0.635322839076439),.UNSPECIFIED.);
#206=EDGE_CURVE('E115',#124,#32,#205,.T.);
#207=ORIENTED_EDGE('',*,*,#206,.T.);
#208=EDGE_LOOP('',(#34,#117,#126,#207));
#209=FACE_BOUND('',#208,.T.);
#210=ADVANCED_FACE('F34',(#209),#23,.T.);
#211=CARTESIAN_POINT('',(-0.70000000000054,2.70000000000017,0.));
#212=DIRECTION('',(1.00000000000003,0.,0.));
#213=DIRECTION('',(0.,0.,-1.00000000000001));
#214=AXIS2_PLACEMENT_3D('',#211,#212,#213);
#215=PLANE('',#214);
#216=DIRECTION('',(0.,0.,-1.00000000000001));
#217=VECTOR('',#216,1.);
#218=CARTESIAN_POINT('',(-0.700000000000464,0.315000000000121,2.85599999999984));
#219=LINE('',#218,#217);
#220=CARTESIAN_POINT('',(-0.700000000000228,0.314999999999987,2.68156204477893));
#221=VERTEX_POINT('',#220);
#222=EDGE_CURVE('E104',#221,#115,#219,.T.);
#223=ORIENTED_EDGE('',*,*,#222,.F.);
#224=CARTESIAN_POINT('',(-0.700000000000464,1.04083408558608E-13,-3.60822483003176E-13));
#225=DIRECTION('',(-1.00000000000003,0.,0.));
#226=DIRECTION('',(0.,0.,1.00000000000001));
#227=AXIS2_PLACEMENT_3D('',#224,#225,#226);
#228=CIRCLE('',#227,2.7);
#229=CARTESIAN_POINT('',(-0.700000000000183,-0.315000000000027,2.68156204477912));
#230=VERTEX_POINT('',#229);
#231=EDGE_CURVE('E133',#221,#230,#228,.T.);
#232=ORIENTED_EDGE('',*,*,#231,.T.);
#233=DIRECTION('',(0.,0.,1.00000000000001));
#234=VECTOR('',#233,1.);
#235=CARTESIAN_POINT('',(-0.700000000000423,-0.314999999999857,-2.08166817117217E-13));
#236=LINE('',#235,#234);
#237=EDGE_CURVE('E116',#124,#230,#236,.T.);
#238=ORIENTED_EDGE('',*,*,#237,.F.);
#239=ORIENTED_EDGE('',*,*,#125,.F.);
#240=EDGE_LOOP('',(#223,#232,#238,#239));
#241=FACE_BOUND('',#240,.T.);
#242=ADVANCED_FACE('F202',(#241),#215,.F.);
#243=CARTESIAN_POINT('',(-0.60000000000042,0.,-2.22044604925031E-13));
#244=DIRECTION('',(-1.00000000000003,0.,0.));
#245=DIRECTION('',(0.,0.,1.00000000000001));
#246=AXIS2_PLACEMENT_3D('',#243,#244,#245);
#247=TOROIDAL_SURFACE('',#246,2.7,0.1);
#248=CARTESIAN_POINT('',(-0.644804107039459,0.314999999999947,2.59152476074374));
#249=CARTESIAN_POINT('',(-0.639819348949186,0.314999999999909,2.58900850086259));
#250=CARTESIAN_POINT('',(-0.634619246510698,0.315000000000079,2.58691012301479));
#251=CARTESIAN_POINT('',(-0.623936442670806,0.315000000000161,2.58361419882402));
#252=CARTESIAN_POINT('',(-0.618453427750353,0.315000000000072,2.58241767584937));
#253=CARTESIAN_POINT('',(-0.607365682893249,0.315000000000052,2.5809637656485));
#254=CARTESIAN_POINT('',(-0.601760996524289,0.315000000000121,2.58070604766122));
#255=CARTESIAN_POINT('',(-0.590589574022697,0.31500000000012,2.58113683412572));
#256=CARTESIAN_POINT('',(-0.585022829213951,0.31500000000005,2.58182511442523));
#257=CARTESIAN_POINT('',(-0.574090964387455,0.315000000000035,2.5841254681744));
#258=CARTESIAN_POINT('',(-0.568725600551778,0.315000000000091,2.58573638341575));
#259=CARTESIAN_POINT('',(-0.558340187533038,0.31500000000015,2.58983372529322));
#260=CARTESIAN_POINT('',(-0.553320153754776,0.315000000000153,2.59232019095646));
#261=CARTESIAN_POINT('',(-0.543752312531997,0.315000000000175,2.59810417992483));
#262=CARTESIAN_POINT('',(-0.539205861737875,0.315000000000192,2.60140394682546));
#263=CARTESIAN_POINT('',(-0.530727063584541,0.315000000000048,2.60871549098382));
#264=CARTESIAN_POINT('',(-0.526794734059067,0.314999999999885,2.6127272889113));
#265=CARTESIAN_POINT('',(-0.519628961930493,0.314999999999916,2.62137586092689));
#266=CARTESIAN_POINT('',(-0.516400094037728,0.31500000000011,2.62601642514383));
#267=CARTESIAN_POINT('',(-0.51076105169881,0.31500000000013,2.6357708027186));
#268=CARTESIAN_POINT('',(-0.508350906971305,0.314999999999954,2.64088463324683));
#269=CARTESIAN_POINT('',(-0.504400953400816,0.314999999999936,2.65147797193056));
#270=CARTESIAN_POINT('',(-0.502867205526944,0.315000000000096,2.65695974046688));
#271=CARTESIAN_POINT('',(-0.500737385767127,0.315000000000144,2.66810254575521));
#272=CARTESIAN_POINT('',(-0.500141341434171,0.315000000000032,2.67376358776992));
#273=CARTESIAN_POINT('',(-0.49990279464194,0.315000000000018,2.68513003679967));
#274=CARTESIAN_POINT('',(-0.500264376562765,0.315000000000116,2.69083553002818));
#275=CARTESIAN_POINT('',(-0.501940226721045,0.315000000000123,2.70210492299341));
#276=CARTESIAN_POINT('',(-0.503254500893128,0.315000000000032,2.70766882184787));
#277=CARTESIAN_POINT('',(-0.506799966570195,0.315000000000001,2.71849626617593));
#278=CARTESIAN_POINT('',(-0.509031122155379,0.315000000000062,2.72375982340653));
#279=CARTESIAN_POINT('',(-0.514348976063041,0.315000000000178,2.7338354900802));
#280=CARTESIAN_POINT('',(-0.517435659595443,0.315000000000235,2.73864760732569));
#281=CARTESIAN_POINT('',(-0.524364138017305,0.315000000000215,2.74766196979638));
#282=CARTESIAN_POINT('',(-0.528202771237035,0.315000000000138,2.75186664470842));
#283=CARTESIAN_POINT('',(-0.536535432023568,0.315000000000102,2.75956685707478));
#284=CARTESIAN_POINT('',(-0.541029437877011,0.315000000000142,2.76306241801382));
#285=CARTESIAN_POINT('',(-0.550515150822746,0.315000000000193,2.76922182012767));
#286=CARTESIAN_POINT('',(-0.555503564472178,0.315000000000205,2.77189073333737));
#287=CARTESIAN_POINT('',(-0.56585952699304,0.315000000000036,2.77634762896194));
#288=CARTESIAN_POINT('',(-0.571227062918684,0.314999999999855,2.77813564144007));
#289=CARTESIAN_POINT('',(-0.582155823196464,0.314999999999877,2.78077003583123));
#290=CARTESIAN_POINT('',(-0.587715761695693,0.315000000000077,2.78162175381095));
#291=CARTESIAN_POINT('',(-0.598899619429549,0.315000000000164,2.78237666704992));
#292=CARTESIAN_POINT('',(-0.604523537289373,0.315000000000051,2.7822798826525));
#293=CARTESIAN_POINT('',(-0.615658569106806,0.314999999999993,2.78114235362454));
#294=CARTESIAN_POINT('',(-0.62116996182357,0.315000000000048,2.78010433464171));
#295=CARTESIAN_POINT('',(-0.631940515980541,0.315000000000193,2.77711867407177));
#296=CARTESIAN_POINT('',(-0.637199677463725,0.315000000000284,2.77517103263965));
#297=CARTESIAN_POINT('',(-0.647323094357031,0.315000000000287,2.7704204738242));
#298=CARTESIAN_POINT('',(-0.652186924283365,0.315000000000198,2.76761664999484));
#299=CARTESIAN_POINT('',(-0.661377628666784,0.315000000000044,2.7612357544302));
#300=CARTESIAN_POINT('',(-0.665704492996637,0.314999999999979,2.75765866811458));
#301=CARTESIAN_POINT('',(-0.673720178457009,0.31500000000001,2.74981583299636));
#302=CARTESIAN_POINT('',(-0.677405986130664,0.315000000000106,2.74554700471167));
#303=CARTESIAN_POINT('',(-0.684013985927648,0.315000000000135,2.73645444447706));
#304=CARTESIAN_POINT('',(-0.686936151622167,0.315000000000068,2.73163069333018));
#305=CARTESIAN_POINT('',(-0.691953421678156,0.315000000000066,2.7215326674091));
#306=CARTESIAN_POINT('',(-0.694043193194004,0.315000000000131,2.71625574291339));
#307=CARTESIAN_POINT('',(-0.69731262663848,0.31500000000011,2.70542709574354));
#308=CARTESIAN_POINT('',(-0.698492256871942,0.315000000000022,2.69987536350654));
#309=CARTESIAN_POINT('',(-0.699913690912734,0.315000000000021,2.68862199929415));
#310=CARTESIAN_POINT('',(-0.700150299679326,0.315000000000108,2.68291971068757));
#311=CARTESIAN_POINT('',(-0.699665186511012,0.315000000000133,2.67155619464161));
#312=CARTESIAN_POINT('',(-0.698943483213151,0.31500000000007,2.66589496640585));
#313=CARTESIAN_POINT('',(-0.696559046040262,0.315000000000074,2.65476146355971));
#314=CARTESIAN_POINT('',(-0.694894294046907,0.315000000000142,2.64928962096812));
#315=CARTESIAN_POINT('',(-0.690667276969469,0.315000000000099,2.63870250442207));
#316=CARTESIAN_POINT('',(-0.688104794118161,0.314999999999989,2.63358731734471));
#317=CARTESIAN_POINT('',(-0.68215902396999,0.314999999999985,2.623871191168));
#318=CARTESIAN_POINT('',(-0.678777152790138,0.315000000000092,2.61926938463912));
#319=CARTESIAN_POINT('',(-0.671286831416816,0.315000000000149,2.61070757735646));
#320=CARTESIAN_POINT('',(-0.667179282419606,0.315000000000101,2.60674679209533));
#321=CARTESIAN_POINT('',(-0.659993972100261,0.315000000000125,2.60091027142458));
#322=CARTESIAN_POINT('',(-0.657098787503452,0.315000000000159,2.59880583649644));
#323=CARTESIAN_POINT('',(-0.651099871926962,0.315000000000082,2.5949187363409));
#324=CARTESIAN_POINT('',(-0.647996141490056,0.314999999999972,2.59313607027609));
#325=CARTESIAN_POINT('',(-0.644804107039459,0.314999999999947,2.59152476074374));
#326=B_SPLINE_CURVE_WITH_KNOTS('',3,(#248,#249,#250,#251,#252,#253,#254,#255,#256,#257,#258,
#259,#260,#261,#262,#263,#264,#265,#266,#267,#268,#269,#270,#271,#272,#273,#274,#275,#276,#277,
#278,#279,#280,#281,#282,#283,#284,#285,#286,#287,#288,#289,#290,#291,#292,#293,#294,#295,#296,
#297,#298,#299,#300,#301,#302,#303,#304,#305,#306,#307,#308,#309,#310,#311,#312,#313,#314,#315,
#316,#317,#318,#319,#320,#321,#322,#323,#324,#325),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.016738560079976,
0.0334960855503899,0.0502477064151701,0.0669953587036507,0.083722033152786,0.100449453277577,
0.117223544993763,0.13399812372962,0.150878733002603,0.167759954955571,0.184756553109657,
0.201753650673558,0.218823359331435,0.23589317432293,0.252962320650069,0.270031171910034,
0.287029738508001,0.304027742048911,0.320919285195535,0.337810251829781,0.354604447359542,
0.371398282690857,0.388143640836856,0.404888996129623,0.421652141671045,0.438415603319246,
0.455255852925762,0.472096685277664,0.489043739214644,0.505991383296766,0.52303226279964,
0.540072810900038,0.557149964178308,0.574231262821682,0.591283248495692,0.608314204827273,
0.619032919460198,0.629751606197057),.UNSPECIFIED.);
#327=CARTESIAN_POINT('',(-0.600000000000198,0.315000000000083,2.78222482916078));
#328=VERTEX_POINT('',#327);
#329=EDGE_CURVE('E147',#328,#221,#326,.T.);
#330=ORIENTED_EDGE('',*,*,#329,.F.);
#331=CARTESIAN_POINT('',(-0.60000000000042,0.,-2.22044604925031E-13));
#332=DIRECTION('',(-1.00000000000003,0.,0.));
#333=DIRECTION('',(0.,0.,1.00000000000001));
#334=AXIS2_PLACEMENT_3D('',#331,#332,#333);
#335=CIRCLE('',#334,2.8);
#336=CARTESIAN_POINT('',(-0.600000000000087,-0.314999999999958,2.78222482916086));
#337=VERTEX_POINT('',#336);
#338=EDGE_CURVE('E130',#328,#337,#335,.T.);
#339=ORIENTED_EDGE('',*,*,#338,.T.);
#340=CARTESIAN_POINT('',(-0.644804107039595,-0.314999999999944,2.59152476074349));
#341=CARTESIAN_POINT('',(-0.649830773602699,-0.314999999999973,2.59406274326791));
#342=CARTESIAN_POINT('',(-0.65464576378696,-0.31499999999985,2.59702943346482));
#343=CARTESIAN_POINT('',(-0.663712095617722,-0.314999999999861,2.60373312579864));
#344=CARTESIAN_POINT('',(-0.66796270874855,-0.314999999999995,2.60747110795741));
#345=CARTESIAN_POINT('',(-0.675774191674622,-0.315000000000004,2.61560396986147));
#346=CARTESIAN_POINT('',(-0.679335596514527,-0.31499999999988,2.61999833531049));
#347=CARTESIAN_POINT('',(-0.685673535256145,-0.31499999999983,2.62931869458694));
#348=CARTESIAN_POINT('',(-0.688450261148415,-0.314999999999905,2.63424455796235));
#349=CARTESIAN_POINT('',(-0.69315725213305,-0.314999999999914,2.64451656338466));
#350=CARTESIAN_POINT('',(-0.695083020190366,-0.314999999999848,2.64986476626436));
#351=CARTESIAN_POINT('',(-0.698014517755106,-0.314999999999863,2.66080789986526));
#352=CARTESIAN_POINT('',(-0.699020181389662,-0.314999999999943,2.66640284822161));
#353=CARTESIAN_POINT('',(-0.700086652833462,-0.314999999999958,2.67771056689333));
#354=CARTESIAN_POINT('',(-0.700142685260381,-0.314999999999891,2.68342378812275));
#355=CARTESIAN_POINT('',(-0.699295840471851,-0.314999999999819,2.69477878030279));
#356=CARTESIAN_POINT('',(-0.698392953418974,-0.314999999999814,2.70042055051982));
#357=CARTESIAN_POINT('',(-0.695651294467337,-0.31499999999981,2.71147773064091));
#358=CARTESIAN_POINT('',(-0.693811635258172,-0.314999999999811,2.71689292065597));
#359=CARTESIAN_POINT('',(-0.689246317463109,-0.3149999999999,2.72733606324439));
#360=CARTESIAN_POINT('',(-0.686520671815334,-0.314999999999989,2.73236402147119));
#361=CARTESIAN_POINT('',(-0.680269526433916,-0.314999999999961,2.74187128908776));
#362=CARTESIAN_POINT('',(-0.676746735960584,-0.314999999999846,2.74635237949648));
#363=CARTESIAN_POINT('',(-0.66899467789807,-0.314999999999865,2.7546550360666));
#364=CARTESIAN_POINT('',(-0.66476543126614,-0.314999999999999,2.75847662178559));
#365=CARTESIAN_POINT('',(-0.655747622839004,-0.315,2.76532704878991));
#366=CARTESIAN_POINT('',(-0.650962579784618,-0.314999999999869,2.76836052193557));
#367=CARTESIAN_POINT('',(-0.640948721390303,-0.314999999999842,2.77357534430373));
#368=CARTESIAN_POINT('',(-0.635719921890468,-0.314999999999947,2.77575672392654));
#369=CARTESIAN_POINT('',(-0.625001137322511,-0.314999999999955,2.77919209986021));
#370=CARTESIAN_POINT('',(-0.619512930231824,-0.31499999999986,2.78045164481094));
#371=CARTESIAN_POINT('',(-0.608402773160228,-0.314999999999851,2.78202770236623));
#372=CARTESIAN_POINT('',(-0.60278082651374,-0.314999999999938,2.7823442384573));
#373=CARTESIAN_POINT('',(-0.591584605691977,-0.314999999999943,2.78202552705797));
#374=CARTESIAN_POINT('',(-0.586010232424212,-0.314999999999862,2.78139374741012));
#375=CARTESIAN_POINT('',(-0.575046718943798,-0.31499999999985,2.77920340006368));
#376=CARTESIAN_POINT('',(-0.569657577733403,-0.314999999999918,2.777644837358));
#377=CARTESIAN_POINT('',(-0.559215843045333,-0.314999999999928,2.77364623524223));
#378=CARTESIAN_POINT('',(-0.554163312956533,-0.314999999999868,2.77120603035843));
#379=CARTESIAN_POINT('',(-0.544537483046782,-0.314999999999844,2.76551518680119));
#380=CARTESIAN_POINT('',(-0.539964190863432,-0.31499999999988,2.76226453521449));
#381=CARTESIAN_POINT('',(-0.531406825248069,-0.314999999999855,2.75503214741555));
#382=CARTESIAN_POINT('',(-0.52742513741568,-0.314999999999794,2.75104758899623));
#383=CARTESIAN_POINT('',(-0.520182277456794,-0.314999999999918,2.7424701449695));
#384=CARTESIAN_POINT('',(-0.516921127521429,-0.315000000000103,2.73787724063322));
#385=CARTESIAN_POINT('',(-0.511190512562501,-0.315000000000083,2.72818340931299));
#386=CARTESIAN_POINT('',(-0.508726028879508,-0.314999999999876,2.72307953760471));
#387=CARTESIAN_POINT('',(-0.504683173708135,-0.314999999999836,2.71253215275059));
#388=CARTESIAN_POINT('',(-0.503104832859738,-0.315000000000002,2.70708862786787));
#389=CARTESIAN_POINT('',(-0.500870093325943,-0.315000000000011,2.69598208598049));
#390=CARTESIAN_POINT('',(-0.500219177866248,-0.314999999999853,2.69031796530688));
#391=CARTESIAN_POINT('',(-0.499874250979565,-0.31499999999986,2.6789606173196));
#392=CARTESIAN_POINT('',(-0.500180260790684,-0.315000000000025,2.67326738936271));
#393=CARTESIAN_POINT('',(-0.501743150815298,-0.315000000000036,2.66199479127906));
#394=CARTESIAN_POINT('',(-0.503002988357604,-0.314999999999881,2.65641583080041));
#395=CARTESIAN_POINT('',(-0.506442484412946,-0.314999999999831,2.64554893253435));
#396=CARTESIAN_POINT('',(-0.508622145452237,-0.314999999999935,2.64026099554626));
#397=CARTESIAN_POINT('',(-0.513838056074992,-0.314999999999953,2.63013398169439));
#398=CARTESIAN_POINT('',(-0.5168732584526,-0.314999999999866,2.62529436563626));
#399=CARTESIAN_POINT('',(-0.52371712705279,-0.314999999999846,2.61619686393619));
#400=CARTESIAN_POINT('',(-0.527525775817143,-0.314999999999911,2.61193896516737));
#401=CARTESIAN_POINT('',(-0.535787628737102,-0.314999999999893,2.60415038344458));
#402=CARTESIAN_POINT('',(-0.540237341795779,-0.31499999999981,2.60061599776733));
#403=CARTESIAN_POINT('',(-0.549670335950193,-0.314999999999902,2.59435089839571));
#404=CARTESIAN_POINT('',(-0.554653574715212,-0.315000000000076,2.59162012100622));
#405=CARTESIAN_POINT('',(-0.564973913994316,-0.315000000000055,2.58706004086597));
#406=CARTESIAN_POINT('',(-0.570308220478065,-0.314999999999863,2.58522441359272));
#407=CARTESIAN_POINT('',(-0.581211701819799,-0.314999999999849,2.58247999704331));
#408=CARTESIAN_POINT('',(-0.58678092730794,-0.315000000000026,2.58157140863799));
#409=CARTESIAN_POINT('',(-0.597963815786665,-0.315000000000035,2.58071102685845));
#410=CARTESIAN_POINT('',(-0.60357711151694,-0.314999999999869,2.58075441711022));
#411=CARTESIAN_POINT('',(-0.614711540831172,-0.314999999999842,2.58178520011238));
#412=CARTESIAN_POINT('',(-0.62023277964582,-0.314999999999981,2.58277142729137));
#413=CARTESIAN_POINT('',(-0.628939788563759,-0.314999999999938,2.58509663589606));
#414=CARTESIAN_POINT('',(-0.63220396215429,-0.314999999999858,2.58615225313916));
#415=CARTESIAN_POINT('',(-0.638606268546872,-0.314999999999853,2.58859388794115));
#416=CARTESIAN_POINT('',(-0.641744401818223,-0.314999999999926,2.58997990426968));
#417=CARTESIAN_POINT('',(-0.644804107039595,-0.314999999999944,2.59152476074349));
#418=B_SPLINE_CURVE_WITH_KNOTS('',3,(#340,#341,#342,#343,#344,#345,#346,#347,#348,#349,#350,
#351,#352,#353,#354,#355,#356,#357,#358,#359,#360,#361,#362,#363,#364,#365,#366,#367,#368,#369,
#370,#371,#372,#373,#374,#375,#376,#377,#378,#379,#380,#381,#382,#383,#384,#385,#386,#387,#388,
#389,#390,#391,#392,#393,#394,#395,#396,#397,#398,#399,#400,#401,#402,#403,#404,#405,#406,#407,
#408,#409,#410,#411,#412,#413,#414,#415,#416,#417),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.0168805294887938,
0.0337826413387401,0.0506715786731578,0.0675563801383617,0.0845293752025179,0.101503585316164,
0.11856312795217,0.135622845601467,0.152698752353572,0.169774409756213,0.186792881227216,
0.203810847929343,0.220726411261632,0.237641371038722,0.254453660842323,0.271265531916805,
0.2880160741981,0.304766526239184,0.321520123774801,0.338273988271448,0.355093677657877,
0.371913884985069,0.388837316839232,0.405761333815496,0.422785001409478,0.439809046831321,
0.456886092317326,0.473963184704991,0.491019464366394,0.508075359076313,0.525041655395014,
0.5420066065789,0.558849892786602,0.575696827824189,0.592458548406472,0.609199574262206,
0.619474701107904,0.629749789691557),.UNSPECIFIED.);
#419=EDGE_CURVE('E195',#230,#337,#418,.T.);
#420=ORIENTED_EDGE('',*,*,#419,.F.);
#421=ORIENTED_EDGE('',*,*,#231,.F.);
#422=EDGE_LOOP('',(#330,#339,#420,#421));
#423=FACE_BOUND('',#422,.T.);
#424=ADVANCED_FACE('F156',(#423),#247,.T.);
#425=CARTESIAN_POINT('',(-34.9250000000016,0.,0.));
#426=DIRECTION('',(-1.00000000000003,0.,0.));
#427=DIRECTION('',(0.,0.,1.00000000000001));
#428=AXIS2_PLACEMENT_3D('',#425,#426,#427);
#429=CYLINDRICAL_SURFACE('',#428,2.8);
#430=DIRECTION('',(-1.00000000000003,0.,0.));
#431=VECTOR('',#430,1.);
#432=CARTESIAN_POINT('',(-34.925000000002,0.314999999999982,2.78222482916081));
#433=LINE('',#432,#431);
#434=CARTESIAN_POINT('',(-0.100000000000242,0.315000000000102,2.78222482916073));
#435=VERTEX_POINT('',#434);
#436=EDGE_CURVE('E148',#435,#328,#433,.T.);
#437=ORIENTED_EDGE('',*,*,#436,.F.);
#438=CARTESIAN_POINT('',(-0.100000000000364,0.,-1.94289029309402E-13));
#439=DIRECTION('',(-1.00000000000003,0.,0.));
#440=DIRECTION('',(0.,0.,1.00000000000001));
#441=AXIS2_PLACEMENT_3D('',#438,#439,#440);
#442=CIRCLE('',#441,2.8);
#443=CARTESIAN_POINT('',(-0.10000000000028,-0.314999999999923,2.78222482916123));
#444=VERTEX_POINT('',#443);
#445=EDGE_CURVE('E122',#435,#444,#442,.T.);
#446=ORIENTED_EDGE('',*,*,#445,.T.);
#447=DIRECTION('',(-1.00000000000003,0.,0.));
#448=VECTOR('',#447,1.);
#449=CARTESIAN_POINT('',(-34.9250000000018,-0.315000000000096,2.78222482916103));
#450=LINE('',#449,#448);
#451=EDGE_CURVE('E192',#337,#444,#450,.F.);
#452=ORIENTED_EDGE('',*,*,#451,.F.);
#453=ORIENTED_EDGE('',*,*,#338,.F.);
#454=EDGE_LOOP('',(#437,#446,#452,#453));
#455=FACE_BOUND('',#454,.T.);
#456=ADVANCED_FACE('F185',(#455),#429,.T.);
#457=CARTESIAN_POINT('',(-0.100000000000364,0.,-1.94289029309402E-13));
#458=DIRECTION('',(-1.00000000000003,0.,0.));
#459=DIRECTION('',(0.,0.,1.00000000000001));
#460=AXIS2_PLACEMENT_3D('',#457,#458,#459);
#461=TOROIDAL_SURFACE('',#460,2.7,0.1);
#462=CARTESIAN_POINT('',(-0.0551958929609665,0.315000000000025,2.59152476074369));
#463=CARTESIAN_POINT('',(-0.0501692263978598,0.314999999999992,2.5940627432681));
#464=CARTESIAN_POINT('',(-0.0453542362136137,0.315000000000083,2.59702943346505));
#465=CARTESIAN_POINT('',(-0.0362879043827667,0.315000000000153,2.60373312579878));
#466=CARTESIAN_POINT('',(-0.0320372912518347,0.315000000000132,2.60747110795743));
#467=CARTESIAN_POINT('',(-0.0242258083258533,0.315000000000113,2.61560396986146));
#468=CARTESIAN_POINT('',(-0.0206644034861393,0.315000000000115,2.61999833531059));
#469=CARTESIAN_POINT('',(-0.0143264647446081,0.315000000000121,2.62931869458706));
#470=CARTESIAN_POINT('',(-0.0115497388522353,0.315000000000126,2.63424455796237));
#471=CARTESIAN_POINT('',(-0.0068427478675797,0.315000000000146,2.64451656338462));
#472=CARTESIAN_POINT('',(-0.00491697981035106,0.315000000000161,2.64986476626436));
#473=CARTESIAN_POINT('',(-0.00198548224573816,0.315000000000075,2.6608078998653));
#474=CARTESIAN_POINT('',(-0.00097981861122313,0.314999999999973,2.66640284822166));
#475=CARTESIAN_POINT('',(8.66528325580926E-05,0.314999999999991,2.67771056689336));
#476=CARTESIAN_POINT('',(0.00014268525950029,0.315000000000111,2.68342378812276));
#477=CARTESIAN_POINT('',(-0.000704159528846999,0.315000000000125,2.69477878030282));
#478=CARTESIAN_POINT('',(-0.00160704658156394,0.315000000000018,2.70042055051987));
#479=CARTESIAN_POINT('',(-0.00434870553322888,0.315000000000016,2.71147773064092));
#480=CARTESIAN_POINT('',(-0.0061883647425853,0.315000000000122,2.71689292065591));
#481=CARTESIAN_POINT('',(-0.0107536825376612,0.315000000000115,2.72733606324434));
#482=CARTESIAN_POINT('',(-0.0134793281852585,0.315000000000002,2.73236402147123));
#483=CARTESIAN_POINT('',(-0.0197304735666368,0.315000000000003,2.74187128908782));
#484=CARTESIAN_POINT('',(-0.0232532640401087,0.315000000000116,2.74635237949648));
#485=CARTESIAN_POINT('',(-0.0310053221027818,0.31500000000012,2.75465503606657));
#486=CARTESIAN_POINT('',(-0.0352345687347319,0.315000000000011,2.75847662178558));
#487=CARTESIAN_POINT('',(-0.0442523771618729,0.315000000000022,2.76532704878989));
#488=CARTESIAN_POINT('',(-0.0490374202162385,0.315000000000141,2.76836052193553));
#489=CARTESIAN_POINT('',(-0.0590512786104477,0.315000000000096,2.77357534430379));
#490=CARTESIAN_POINT('',(-0.0642800781101959,0.314999999999933,2.77575672392672));
#491=CARTESIAN_POINT('',(-0.0749988626780984,0.314999999999927,2.77919209986037));
#492=CARTESIAN_POINT('',(-0.0804870697688173,0.315000000000083,2.78045164481095));
#493=CARTESIAN_POINT('',(-0.0915972268404451,0.315000000000154,2.78202770236619));
#494=CARTESIAN_POINT('',(-0.0972191734869318,0.315000000000069,2.78234423845735));
#495=CARTESIAN_POINT('',(-0.10841539430869,0.315000000000048,2.78202552705806));
#496=CARTESIAN_POINT('',(-0.113989767576449,0.315000000000111,2.78139374741014));
#497=CARTESIAN_POINT('',(-0.124953281056859,0.315000000000126,2.77920340006371));
#498=CARTESIAN_POINT('',(-0.130342422267254,0.315000000000078,2.7776448373581));
#499=CARTESIAN_POINT('',(-0.140784156955299,0.315000000000067,2.77364623524242));
#500=CARTESIAN_POINT('',(-0.145836687044076,0.315000000000104,2.77120603035862));
#501=CARTESIAN_POINT('',(-0.155462516953661,0.315000000000133,2.76551518680131));
#502=CARTESIAN_POINT('',(-0.160035809136868,0.315000000000126,2.7622645352145));
#503=CARTESIAN_POINT('',(-0.168593174752352,0.315000000000144,2.75503214741564));
#504=CARTESIAN_POINT('',(-0.172574862584997,0.315000000000169,2.75104758899648));
#505=CARTESIAN_POINT('',(-0.179817722543808,0.315000000000068,2.74247014496961));
#506=CARTESIAN_POINT('',(-0.18307887247884,0.314999999999941,2.73787724063303));
#507=CARTESIAN_POINT('',(-0.188809487437804,0.314999999999957,2.72818340931274));
#508=CARTESIAN_POINT('',(-0.191273971121184,0.315000000000101,2.72307953760469));
#509=CARTESIAN_POINT('',(-0.195316826292685,0.315000000000137,2.71253215275078));
#510=CARTESIAN_POINT('',(-0.196895167140824,0.31500000000003,2.70708862786802));
#511=CARTESIAN_POINT('',(-0.19912990667462,0.315000000000007,2.69598208598053));
#512=CARTESIAN_POINT('',(-0.199780822134551,0.315000000000093,2.69031796530684));
#513=CARTESIAN_POINT('',(-0.200125749021218,0.315000000000145,2.67896061731938));
#514=CARTESIAN_POINT('',(-0.199819739209848,0.315000000000112,2.6732673893624));
#515=CARTESIAN_POINT('',(-0.198256849185196,0.315000000000116,2.66199479127863));
#516=CARTESIAN_POINT('',(-0.19699701164313,0.315000000000154,2.65641583079996));
#517=CARTESIAN_POINT('',(-0.193557515587668,0.315000000000083,2.64554893253407));
#518=CARTESIAN_POINT('',(-0.191377854548016,0.314999999999974,2.64026099554618));
#519=CARTESIAN_POINT('',(-0.186161943925237,0.315,2.63013398169434));
#520=CARTESIAN_POINT('',(-0.183126741547966,0.315000000000134,2.62529436563606));
#521=CARTESIAN_POINT('',(-0.176282872947957,0.315000000000103,2.61619686393604));
#522=CARTESIAN_POINT('',(-0.172474224183447,0.314999999999937,2.61193896516742));
#523=CARTESIAN_POINT('',(-0.164212371263463,0.31499999999994,2.60415038344466));
#524=CARTESIAN_POINT('',(-0.159762658204907,0.315000000000106,2.60061599776725));
#525=CARTESIAN_POINT('',(-0.150329664050493,0.315000000000131,2.59435089839565));
#526=CARTESIAN_POINT('',(-0.145346425285352,0.31499999999999,2.59162012100634));
#527=CARTESIAN_POINT('',(-0.135026086006157,0.314999999999974,2.58706004086611));
#528=CARTESIAN_POINT('',(-0.129691779522436,0.315000000000095,2.58522441359271));
#529=CARTESIAN_POINT('',(-0.118788298180652,0.315000000000141,2.58247999704316));
#530=CARTESIAN_POINT('',(-0.113219072692434,0.315000000000065,2.58157140863787));
#531=CARTESIAN_POINT('',(-0.102036184213667,0.315000000000058,2.58071102685849));
#532=CARTESIAN_POINT('',(-0.0964228884834284,0.315000000000126,2.58075441711038));
#533=CARTESIAN_POINT('',(-0.0852884591691821,0.31500000000011,2.5817852001123));
#534=CARTESIAN_POINT('',(-0.0797672203544831,0.315000000000026,2.58277142729092));
#535=CARTESIAN_POINT('',(-0.0710602114366556,0.315000000000067,2.58509663589579));
#536=CARTESIAN_POINT('',(-0.0677960378462087,0.315000000000123,2.58615225313914));
#537=CARTESIAN_POINT('',(-0.0613937314537005,0.315000000000113,2.58859388794136));
#538=CARTESIAN_POINT('',(-0.0582555981823401,0.315000000000046,2.58997990426988));
#539=CARTESIAN_POINT('',(-0.0551958929609665,0.315000000000025,2.59152476074369));
#540=B_SPLINE_CURVE_WITH_KNOTS('',3,(#462,#463,#464,#465,#466,#467,#468,#469,#470,#471,#472,
#473,#474,#475,#476,#477,#478,#479,#480,#481,#482,#483,#484,#485,#486,#487,#488,#489,#490,#491,
#492,#493,#494,#495,#496,#497,#498,#499,#500,#501,#502,#503,#504,#505,#506,#507,#508,#509,#510,
#511,#512,#513,#514,#515,#516,#517,#518,#519,#520,#521,#522,#523,#524,#525,#526,#527,#528,#529,
#530,#531,#532,#533,#534,#535,#536,#537,#538,#539),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.0168805294888305,
0.0337826413387291,0.0506715786730358,0.0675563801381682,0.0845293752023142,0.101503585315957,
0.118563127951948,0.13562284560121,0.152698752353304,0.169774409755936,0.186792881227017,
0.203810847929253,0.220726411261474,0.237641371038449,0.254453660842036,0.27126553191655,
0.288016074197838,0.304766526238885,0.321520123774374,0.3382739882709,0.355093677657482,
0.371913884984847,0.388837316838893,0.405761333815016,0.422785001409321,0.439809046831493,
0.456886092317377,0.47396318470494,0.491019464366216,0.508075359075975,0.5250416553947,
0.542006606578626,0.558849892786445,0.57569682782418,0.59245854840644,0.609199574262075,
0.619474701107754,0.629749789691431),.UNSPECIFIED.);
#541=CARTESIAN_POINT('',(-5.86336534880161E-13,0.314999999999996,2.68156204477896));
#542=VERTEX_POINT('',#541);
#543=EDGE_CURVE('E177',#542,#435,#540,.T.);
#544=ORIENTED_EDGE('',*,*,#543,.F.);
#545=CARTESIAN_POINT('',(0.,0.,0.));
#546=DIRECTION('',(-1.00000000000003,0.,0.));
#547=DIRECTION('',(0.,0.,1.00000000000001));
#548=AXIS2_PLACEMENT_3D('',#545,#546,#547);
#549=CIRCLE('',#548,2.7);
#550=CARTESIAN_POINT('',(-2.46330733588707E-13,-0.31499999999992,2.68156204477919));
#551=VERTEX_POINT('',#550);
#552=EDGE_CURVE('E120',#542,#551,#549,.T.);
#553=ORIENTED_EDGE('',*,*,#552,.T.);
#554=CARTESIAN_POINT('',(-0.0551958929608763,-0.314999999999975,2.59152476074354));
#555=CARTESIAN_POINT('',(-0.0601806510510333,-0.315000000000002,2.58900850086227));
#556=CARTESIAN_POINT('',(-0.0653807534896651,-0.314999999999877,2.58691012301487));
#557=CARTESIAN_POINT('',(-0.0760635573296231,-0.314999999999838,2.5836141988243));
#558=CARTESIAN_POINT('',(-0.0815465722499981,-0.314999999999923,2.58241767584945));
#559=CARTESIAN_POINT('',(-0.0926343171070845,-0.314999999999923,2.58096376564849));
#560=CARTESIAN_POINT('',(-0.0982390034761062,-0.314999999999837,2.58070604766132));
#561=CARTESIAN_POINT('',(-0.109410425977832,-0.314999999999878,2.58113683412572));
#562=CARTESIAN_POINT('',(-0.114977170786649,-0.315000000000006,2.58182511442501));
#563=CARTESIAN_POINT('',(-0.125909035613208,-0.314999999999985,2.58412546817418));
#564=CARTESIAN_POINT('',(-0.131274399448876,-0.314999999999837,2.58573638341575));
#565=CARTESIAN_POINT('',(-0.141659812467731,-0.314999999999877,2.58983372529328));
#566=CARTESIAN_POINT('',(-0.146679846246118,-0.315000000000066,2.59232019095636));
#567=CARTESIAN_POINT('',(-0.156247687468934,-0.315000000000065,2.59810417992469));
#568=CARTESIAN_POINT('',(-0.160794138262975,-0.314999999999875,2.60140394682542));
#569=CARTESIAN_POINT('',(-0.16927293641612,-0.31499999999984,2.60871549098392));
#570=CARTESIAN_POINT('',(-0.173205265941487,-0.314999999999995,2.61272728891145));
#571=CARTESIAN_POINT('',(-0.180371038070097,-0.315000000000032,2.62137586092696));
#572=CARTESIAN_POINT('',(-0.183599905963009,-0.314999999999912,2.62601642514379));
#573=CARTESIAN_POINT('',(-0.189238948301879,-0.314999999999802,2.6357708027185));
#574=CARTESIAN_POINT('',(-0.19164909302919,-0.314999999999811,2.64088463324679));
#575=CARTESIAN_POINT('',(-0.195599046599703,-0.314999999999813,2.65147797193052));
#576=CARTESIAN_POINT('',(-0.197132794473791,-0.314999999999806,2.65695974046677));
#577=CARTESIAN_POINT('',(-0.199262614233643,-0.314999999999908,2.66810254575506));
#578=CARTESIAN_POINT('',(-0.199858658566417,-0.315000000000017,2.67376358776978));
#579=CARTESIAN_POINT('',(-0.2000972053587,-0.314999999999995,2.68513003679959));
#580=CARTESIAN_POINT('',(-0.199735623438106,-0.314999999999864,2.69083553002815));
#581=CARTESIAN_POINT('',(-0.198059773279684,-0.31499999999985,2.70210492299338));
#582=CARTESIAN_POINT('',(-0.196745499107228,-0.314999999999967,2.70766882184778));
#583=CARTESIAN_POINT('',(-0.193200033430143,-0.314999999999955,2.71849626617592));
#584=CARTESIAN_POINT('',(-0.190968877845322,-0.314999999999825,2.72375982340665));
#585=CARTESIAN_POINT('',(-0.18565102393778,-0.314999999999889,2.7338354900803));
#586=CARTESIAN_POINT('',(-0.182564340405135,-0.315000000000082,2.73864760732563));
#587=CARTESIAN_POINT('',(-0.175635861983213,-0.315000000000097,2.74766196979627));
#588=CARTESIAN_POINT('',(-0.171797228763665,-0.31499999999992,2.75186664470843));
#589=CARTESIAN_POINT('',(-0.163464567977301,-0.314999999999795,2.75956685707489));
#590=CARTESIAN_POINT('',(-0.158970562123847,-0.314999999999847,2.76306241801389));
#591=CARTESIAN_POINT('',(-0.149484849178084,-0.31499999999986,2.76922182012773));
#592=CARTESIAN_POINT('',(-0.14449643552863,-0.314999999999821,2.77189073333746));
#593=CARTESIAN_POINT('',(-0.134140473007684,-0.314999999999893,2.77634762896198));
#594=CARTESIAN_POINT('',(-0.128772937081978,-0.315000000000004,2.77813564144005));
#595=CARTESIAN_POINT('',(-0.117844176804101,-0.314999999999981,2.78077003583122));
#596=CARTESIAN_POINT('',(-0.112284238304837,-0.314999999999849,2.78162175381101));
#597=CARTESIAN_POINT('',(-0.101100380570906,-0.314999999999865,2.78237666705001));
#598=CARTESIAN_POINT('',(-0.0954764627110412,-0.315000000000013,2.78227988265254));
#599=CARTESIAN_POINT('',(-0.0843414308936323,-0.315000000000013,2.78114235362452));
#600=CARTESIAN_POINT('',(-0.0788300381769306,-0.314999999999865,2.78010433464168));
#601=CARTESIAN_POINT('',(-0.0680594840200488,-0.31499999999985,2.77711867407177));
#602=CARTESIAN_POINT('',(-0.062800322536892,-0.314999999999982,2.77517103263968));
#603=CARTESIAN_POINT('',(-0.0526769056435766,-0.314999999999988,2.77042047382417));
#604=CARTESIAN_POINT('',(-0.0478130757172146,-0.314999999999862,2.7676166499947));
#605=CARTESIAN_POINT('',(-0.0386223713335905,-0.314999999999854,2.76123575443002));
#606=CARTESIAN_POINT('',(-0.0342955070035582,-0.314999999999972,2.75765866811449));
#607=CARTESIAN_POINT('',(-0.0262798215432544,-0.314999999999971,2.74981583299625));
#608=CARTESIAN_POINT('',(-0.02259401386983,-0.314999999999849,2.74554700471147));
#609=CARTESIAN_POINT('',(-0.0159860140730612,-0.314999999999866,2.73645444447686));
#610=CARTESIAN_POINT('',(-0.0130638483785297,-0.315000000000004,2.73163069333007));
#611=CARTESIAN_POINT('',(-0.00804657832260202,-0.315000000000022,2.72153266740906));
#612=CARTESIAN_POINT('',(-0.00595680680683786,-0.3149999999999,2.71625574291333));
#613=CARTESIAN_POINT('',(-0.00268737336219606,-0.314999999999815,2.70542709574352));
#614=CARTESIAN_POINT('',(-0.00150774312848313,-0.314999999999853,2.69987536350657));
#615=CARTESIAN_POINT('',(-8.63090877688603E-05,-0.314999999999855,2.68862199929423));
#616=CARTESIAN_POINT('',(0.000150299678490963,-0.314999999999819,2.68291971068766));
#617=CARTESIAN_POINT('',(-0.000334813489727101,-0.314999999999897,2.67155619464166));
#618=CARTESIAN_POINT('',(-0.00105651678716007,-0.315000000000011,2.66589496640584));
#619=CARTESIAN_POINT('',(-0.00344095396002159,-0.315000000000015,2.65476146355974));
#620=CARTESIAN_POINT('',(-0.00510570595378263,-0.314999999999904,2.64928962096824));
#621=CARTESIAN_POINT('',(-0.00933272303138224,-0.314999999999811,2.63870250442215));
#622=CARTESIAN_POINT('',(-0.0118952058824458,-0.314999999999829,2.63358731734464));
#623=CARTESIAN_POINT('',(-0.0178409760306116,-0.314999999999844,2.62387119116791));
#624=CARTESIAN_POINT('',(-0.0212228472107046,-0.314999999999841,2.61926938463916));
#625=CARTESIAN_POINT('',(-0.0287131685840763,-0.314999999999875,2.61070757735635));
#626=CARTESIAN_POINT('',(-0.0328207175810954,-0.314999999999911,2.60674679209494));
#627=CARTESIAN_POINT('',(-0.0400060279005081,-0.314999999999874,2.60091027142439));
#628=CARTESIAN_POINT('',(-0.0429012124973987,-0.314999999999837,2.5988058364965));
#629=CARTESIAN_POINT('',(-0.0489001280737361,-0.314999999999879,2.59491873634097));
#630=CARTESIAN_POINT('',(-0.0520038585104092,-0.314999999999958,2.59313607027592));
#631=CARTESIAN_POINT('',(-0.0551958929608763,-0.314999999999975,2.59152476074354));
#632=B_SPLINE_CURVE_WITH_KNOTS('',3,(#554,#555,#556,#557,#558,#559,#560,#561,#562,#563,#564,
#565,#566,#567,#568,#569,#570,#571,#572,#573,#574,#575,#576,#577,#578,#579,#580,#581,#582,#583,
#584,#585,#586,#587,#588,#589,#590,#591,#592,#593,#594,#595,#596,#597,#598,#599,#600,#601,#602,
#603,#604,#605,#606,#607,#608,#609,#610,#611,#612,#613,#614,#615,#616,#617,#618,#619,#620,#621,
#622,#623,#624,#625,#626,#627,#628,#629,#630,#631),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.0167385600798789,
0.0334960855502444,0.0502477064151841,0.06699535870379,0.0837220331530774,0.100449453278024,
0.117223544994128,0.133998123729916,0.15087873300283,0.167759954955723,0.184756553109809,
0.201753650673696,0.218823359331658,0.23589317432326,0.252962320650359,0.270031171910278,
0.287029738508193,0.304027742049033,0.320919285195745,0.337810251830113,0.354604447360017,
0.371398282691439,0.388143640837271,0.404888996129912,0.421652141671605,0.438415603320028,
0.455255852926291,0.472096685277993,0.489043739214971,0.505991383297055,0.523032262799902,
0.540072810900279,0.557149964178617,0.574231262822067,0.591283248496207,0.608314204827924,
0.619032919460617,0.62975160619723),.UNSPECIFIED.);
#633=EDGE_CURVE('E99',#444,#551,#632,.T.);
#634=ORIENTED_EDGE('',*,*,#633,.F.);
#635=ORIENTED_EDGE('',*,*,#445,.F.);
#636=EDGE_LOOP('',(#544,#553,#634,#635));
#637=FACE_BOUND('',#636,.T.);
#638=ADVANCED_FACE('F181',(#637),#461,.T.);
#639=CARTESIAN_POINT('',(-3.2612801348364E-13,1.45000000000012,-3.46944695195361E-13));
#640=DIRECTION('',(-1.00000000000003,0.,0.));
#641=DIRECTION('',(0.,0.,1.00000000000001));
#642=AXIS2_PLACEMENT_3D('',#639,#640,#641);
#643=PLANE('',#642);
#644=DIRECTION('',(0.,0.,-1.00000000000001));
#645=VECTOR('',#644,1.);
#646=CARTESIAN_POINT('',(-4.05925293378573E-13,0.315000000000093,2.85599999999986));
#647=LINE('',#646,#645);
#648=CARTESIAN_POINT('',(-3.64291929955129E-13,0.315000000000017,1.41537097610485));
#649=VERTEX_POINT('',#648);
#650=EDGE_CURVE('E105',#542,#649,#647,.T.);
#651=ORIENTED_EDGE('',*,*,#650,.T.);
#652=CARTESIAN_POINT('',(0.,0.,0.));
#653=DIRECTION('',(-1.00000000000003,0.,0.));
#654=DIRECTION('',(0.,0.,1.00000000000001));
#655=AXIS2_PLACEMENT_3D('',#652,#653,#654);
#656=CIRCLE('',#655,1.45);
#657=CARTESIAN_POINT('',(-2.4980018054066E-13,-0.314999999999802,1.41537097610475));
#658=VERTEX_POINT('',#657);
#659=EDGE_CURVE('E112',#649,#658,#656,.T.);
#660=ORIENTED_EDGE('',*,*,#659,.T.);
#661=DIRECTION('',(0.,0.,1.00000000000001));
#662=VECTOR('',#661,1.);
#663=CARTESIAN_POINT('',(-2.22044604925031E-13,-0.314999999999746,-2.63677968348475E-13));
#664=LINE('',#663,#662);
#665=EDGE_CURVE('E96',#658,#551,#664,.T.);
#666=ORIENTED_EDGE('',*,*,#665,.T.);
#667=ORIENTED_EDGE('',*,*,#552,.F.);
#668=EDGE_LOOP('',(#651,#660,#666,#667));
#669=FACE_BOUND('',#668,.T.);
#670=ADVANCED_FACE('F119',(#669),#643,.F.);
#671=CARTESIAN_POINT('',(-0.100000000000364,0.,-1.94289029309402E-13));
#672=DIRECTION('',(-1.00000000000003,0.,0.));
#673=DIRECTION('',(0.,0.,1.00000000000001));
#674=AXIS2_PLACEMENT_3D('',#671,#672,#673);
#675=TOROIDAL_SURFACE('',#674,1.45,0.1);
#676=ORIENTED_EDGE('',*,*,#659,.F.);
#677=CARTESIAN_POINT('',(-0.0550288065377137,0.315000000000093,1.32371909110271));
#678=CARTESIAN_POINT('',(-0.059908266270329,0.315000000000085,1.32119394292438));
#679=CARTESIAN_POINT('',(-0.0650014477095888,0.315000000000113,1.3190742103696));
#680=CARTESIAN_POINT('',(-0.0754746727453753,0.315000000000122,1.31571662868081));
#681=CARTESIAN_POINT('',(-0.0808549797872918,0.315000000000104,1.31447960494477));
#682=CARTESIAN_POINT('',(-0.0917478998734984,0.315000000000116,1.31293065478832));
#683=CARTESIAN_POINT('',(-0.0972605157354533,0.315000000000145,1.31261874808696));
#684=CARTESIAN_POINT('',(-0.108257913233096,0.315000000000089,1.31293094680862));
#685=CARTESIAN_POINT('',(-0.113742700383923,0.315000000000004,1.31355485886901));
#686=CARTESIAN_POINT('',(-0.124499527138751,0.315000000000008,1.31571134334361));
#687=CARTESIAN_POINT('',(-0.129772552835466,0.315000000000097,1.31723900752961));
#688=CARTESIAN_POINT('',(-0.139991257098654,0.315000000000138,1.32114923206445));
#689=CARTESIAN_POINT('',(-0.14493691580181,0.31500000000009,1.32353184423188));
#690=CARTESIAN_POINT('',(-0.154417186321159,0.315000000000082,1.32910564793981));
#691=CARTESIAN_POINT('',(-0.158947086355943,0.315000000000124,1.3323048458668));
#692=CARTESIAN_POINT('',(-0.167421238446714,0.315000000000112,1.33940208524454));
#693=CARTESIAN_POINT('',(-0.171365427505778,0.315000000000058,1.34330020176902));
#694=CARTESIAN_POINT('',(-0.178655965871187,0.315000000000051,1.35178163004012));
#695=CARTESIAN_POINT('',(-0.181986072044325,0.315000000000101,1.35637890121276));
#696=CARTESIAN_POINT('',(-0.187849545919474,0.315000000000135,1.36605607815435));
#697=CARTESIAN_POINT('',(-0.190382808943432,0.31500000000012,1.37113604721933));
#698=CARTESIAN_POINT('',(-0.194645358691636,0.315000000000101,1.38177149867461));
#699=CARTESIAN_POINT('',(-0.196352859463881,0.315000000000097,1.3873357184247));
#700=CARTESIAN_POINT('',(-0.198825404093783,0.315000000000139,1.39866989498811));
#701=CARTESIAN_POINT('',(-0.199590353119522,0.315000000000186,1.40443987244303));
#702=CARTESIAN_POINT('',(-0.200162413936739,0.315000000000191,1.41611617047468));
#703=CARTESIAN_POINT('',(-0.199954669063344,0.315000000000149,1.42202322547417));
#704=CARTESIAN_POINT('',(-0.198550347234511,0.315000000000087,1.43371890466781));
#705=CARTESIAN_POINT('',(-0.19735374799045,0.315000000000068,1.43950752618947));
#706=CARTESIAN_POINT('',(-0.194000296028265,0.315000000000087,1.4507975951485));
#707=CARTESIAN_POINT('',(-0.191843821112313,0.315000000000124,1.45629915462113));
#708=CARTESIAN_POINT('',(-0.186624526214346,0.315000000000112,1.4668544731427));
#709=CARTESIAN_POINT('',(-0.183561764526904,0.315000000000063,1.47190826096625));
#710=CARTESIAN_POINT('',(-0.176661938889216,0.315000000000078,1.48134337143236));
#711=CARTESIAN_POINT('',(-0.172836839893521,0.315000000000141,1.48573343922672));
#712=CARTESIAN_POINT('',(-0.164489316809146,0.315000000000094,1.49379149610151));
#713=CARTESIAN_POINT('',(-0.159966976073195,0.314999999999984,1.49745957137438));
#714=CARTESIAN_POINT('',(-0.150457896068094,0.315000000000008,1.50388517415352));
#715=CARTESIAN_POINT('',(-0.145483264743417,0.315000000000136,1.5066606204663));
#716=CARTESIAN_POINT('',(-0.13513191817163,0.315000000000099,1.51131790593111));
#717=CARTESIAN_POINT('',(-0.129755250783336,0.314999999999933,1.51319985125108));
#718=CARTESIAN_POINT('',(-0.118864413075229,0.314999999999944,1.51598126477734));
#719=CARTESIAN_POINT('',(-0.113354906013306,0.315000000000115,1.51689901143784));
#720=CARTESIAN_POINT('',(-0.102260194685034,0.31500000000012,1.51778634446005));
#721=CARTESIAN_POINT('',(-0.0966749958909495,0.314999999999955,1.51775599900404));
#722=CARTESIAN_POINT('',(-0.0856453924949222,0.31499999999995,1.51675324335795));
#723=CARTESIAN_POINT('',(-0.0802001443240167,0.315000000000108,1.51579007399153));
#724=CARTESIAN_POINT('',(-0.0695479923726183,0.315000000000127,1.51296573131843));
#725=CARTESIAN_POINT('',(-0.0643410876676756,0.314999999999988,1.51110456149511));
#726=CARTESIAN_POINT('',(-0.054295083530299,0.314999999999979,1.50653525278008));
#727=CARTESIAN_POINT('',(-0.0494571098105456,0.315000000000109,1.50382464123205));
#728=CARTESIAN_POINT('',(-0.0402964187784949,0.315000000000125,1.49764063049652));
#729=CARTESIAN_POINT('',(-0.0359737313184608,0.315000000000011,1.4941671871487));
#730=CARTESIAN_POINT('',(-0.0278977721675604,0.314999999999987,1.48650445037803));
#731=CARTESIAN_POINT('',(-0.0241536313571426,0.315000000000081,1.48230553797726));
#732=CARTESIAN_POINT('',(-0.0174061599364146,0.315000000000154,1.47334980855383));
#733=CARTESIAN_POINT('',(-0.0144029057364822,0.315000000000134,1.46859293406107));
#734=CARTESIAN_POINT('',(-0.00915553243363826,0.315000000000122,1.45855015969758));
#735=CARTESIAN_POINT('',(-0.00692861545895533,0.31500000000013,1.45325527196184));
#736=CARTESIAN_POINT('',(-0.00337580708301976,0.315000000000104,1.442371405223));
#737=CARTESIAN_POINT('',(-0.00205001725247851,0.31500000000007,1.4367823931441));
#738=CARTESIAN_POINT('',(-0.000312350938600675,0.315000000000071,1.4253505919335));
#739=CARTESIAN_POINT('',(8.09126938229496E-05,0.315000000000109,1.41950496921294));
#740=CARTESIAN_POINT('',(-0.000108569310071106,0.315000000000125,1.40782957159719));
#741=CARTESIAN_POINT('',(-0.000691356542561598,0.315000000000104,1.40199979738801));
#742=CARTESIAN_POINT('',(-0.00282839436294659,0.31500000000011,1.39045920405655));
#743=CARTESIAN_POINT('',(-0.00439248900332276,0.315000000000138,1.38475020375473));
#744=CARTESIAN_POINT('',(-0.00846211546667429,0.315000000000096,1.37367605779147));
#745=CARTESIAN_POINT('',(-0.0109678806762648,0.315000000000026,1.36831099775948));
#746=CARTESIAN_POINT('',(-0.0168423216760938,0.315000000000031,1.35810950321952));
#747=CARTESIAN_POINT('',(-0.0202069309025822,0.315000000000105,1.35327072669065));
#748=CARTESIAN_POINT('',(-0.0277140426431042,0.315000000000129,1.34424619013126));
#749=CARTESIAN_POINT('',(-0.0318555208419049,0.315000000000079,1.3400595833591));
#750=CARTESIAN_POINT('',(-0.0391948478993757,0.315000000000088,1.33383215889393));
#751=CARTESIAN_POINT('',(-0.0421994235250411,0.315000000000115,1.33155984917785));
#752=CARTESIAN_POINT('',(-0.0484455234676657,0.31500000000012,1.32736800944886));
#753=CARTESIAN_POINT('',(-0.0516870432168011,0.315000000000098,1.32544847263768));
#754=CARTESIAN_POINT('',(-0.0550288065377137,0.315000000000093,1.32371909110271));
#755=B_SPLINE_CURVE_WITH_KNOTS('',3,(#677,#678,#679,#680,#681,#682,#683,#684,#685,#686,#687,
#688,#689,#690,#691,#692,#693,#694,#695,#696,#697,#698,#699,#700,#701,#702,#703,#704,#705,#706,
#707,#708,#709,#710,#711,#712,#713,#714,#715,#716,#717,#718,#719,#720,#721,#722,#723,#724,#725,
#726,#727,#728,#729,#730,#731,#732,#733,#734,#735,#736,#737,#738,#739,#740,#741,#742,#743,#744,
#745,#746,#747,#748,#749,#750,#751,#752,#753,#754),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.0164689397158711,
0.0329532589988736,0.0494379296459706,0.0659191946335088,0.0823117620265042,0.0987053231447339,
0.115266244495047,0.131828945789191,0.148781202974309,0.165735686179581,0.18311591200932,
0.200497886353785,0.218146206803316,0.235794925054094,0.253436702993353,0.271077346417063,
0.288460287700847,0.30584115252582,0.322847460511536,0.339851747260684,0.356527521361297,
0.373202096222206,0.38971315986736,0.406224159466525,0.422783674831068,0.439344149078179,
0.456143927774358,0.472945438370219,0.490098563006441,0.507253620739771,0.524748306083985,
0.542243737014826,0.559917544025411,0.577595734260232,0.595191723929753,0.612764674013313,
0.624043865236812,0.635322839076673),.UNSPECIFIED.);
#756=CARTESIAN_POINT('',(-0.100000000000353,0.315000000000228,1.31273569312335));
#757=VERTEX_POINT('',#756);
#758=EDGE_CURVE('E169',#649,#757,#755,.T.);
#759=ORIENTED_EDGE('',*,*,#758,.T.);
#760=CARTESIAN_POINT('',(-0.100000000000364,0.,-1.94289029309402E-13));
#761=DIRECTION('',(-1.00000000000003,0.,0.));
#762=DIRECTION('',(0.,0.,1.00000000000001));
#763=AXIS2_PLACEMENT_3D('',#760,#761,#762);
#764=CIRCLE('',#763,1.35);
#765=CARTESIAN_POINT('',(-0.100000000000197,-0.314999999999944,1.31273569312344));
#766=VERTEX_POINT('',#765);
#767=EDGE_CURVE('E114',#757,#766,#764,.T.);
#768=ORIENTED_EDGE('',*,*,#767,.T.);
#769=CARTESIAN_POINT('',(-0.0550288065375021,-0.314999999999881,1.32371909110253));
#770=CARTESIAN_POINT('',(-0.0499899414693526,-0.314999999999887,1.32632732083838));
#771=CARTESIAN_POINT('',(-0.0451715737062894,-0.314999999999834,1.32937191075767));
#772=CARTESIAN_POINT('',(-0.036114607714493,-0.314999999999884,1.33623471928771));
#773=CARTESIAN_POINT('',(-0.0318768909589707,-0.314999999999988,1.34005409274884));
#774=CARTESIAN_POINT('',(-0.0241043953483741,-0.314999999999983,1.34833972508512));
#775=CARTESIAN_POINT('',(-0.0205685056549754,-0.314999999999875,1.35280494204729));
#776=CARTESIAN_POINT('',(-0.0142809806003602,-0.314999999999842,1.3622544629665));
#777=CARTESIAN_POINT('',(-0.0115291514528791,-0.314999999999917,1.36723863824267));
#778=CARTESIAN_POINT('',(-0.00682942256729377,-0.314999999999936,1.37768789684136));
#779=CARTESIAN_POINT('',(-0.00489794647968283,-0.314999999999877,1.38316036787891));
#780=CARTESIAN_POINT('',(-0.00196352933138023,-0.31499999999984,1.39434924391756));
#781=CARTESIAN_POINT('',(-0.000960728832676088,-0.314999999999861,1.40006568570853));
#782=CARTESIAN_POINT('',(0.00010000941115877,-0.314999999999853,1.41168448425184));
#783=CARTESIAN_POINT('',(0.00014150781002288,-0.314999999999822,1.41758834871261));
#784=CARTESIAN_POINT('',(-0.00076518254671605,-0.314999999999895,1.42931987043469));
#785=CARTESIAN_POINT('',(-0.00171340390641147,-0.314999999999999,1.43514752517905));
#786=CARTESIAN_POINT('',(-0.00458041937112139,-0.314999999999986,1.4465697185345));
#787=CARTESIAN_POINT('',(-0.00650081645821737,-0.314999999999869,1.45216385556378));
#788=CARTESIAN_POINT('',(-0.0112657504054051,-0.314999999999849,1.46294399230213));
#789=CARTESIAN_POINT('',(-0.0141102345445008,-0.314999999999945,1.46813001527394));
#790=CARTESIAN_POINT('',(-0.0206058618944848,-0.314999999999935,1.47787151712397));
#791=CARTESIAN_POINT('',(-0.0242459208384081,-0.314999999999831,1.48243438236776));
#792=CARTESIAN_POINT('',(-0.0322555220675558,-0.314999999999886,1.49086759516333));
#793=CARTESIAN_POINT('',(-0.0366249811566815,-0.315000000000045,1.49473802159117));
#794=CARTESIAN_POINT('',(-0.0458703008759904,-0.315000000000071,1.50158857698075));
#795=CARTESIAN_POINT('',(-0.0507334734692001,-0.314999999999944,1.5045858286633));
#796=CARTESIAN_POINT('',(-0.060901868843371,-0.314999999999773,1.50970183608975));
#797=CARTESIAN_POINT('',(-0.0662070374052886,-0.31499999999973,1.51182069939438));
#798=CARTESIAN_POINT('',(-0.0769940205288546,-0.314999999999754,1.51507739409555));
#799=CARTESIAN_POINT('',(-0.0824701534125642,-0.314999999999819,1.51623406003719));
#800=CARTESIAN_POINT('',(-0.0935392154421449,-0.314999999999897,1.51759993853065));
#801=CARTESIAN_POINT('',(-0.0991321352969192,-0.31499999999991,1.51780922616573));
#802=CARTESIAN_POINT('',(-0.110208968930895,-0.31499999999988,1.51727675243744));
#803=CARTESIAN_POINT('',(-0.115693400758004,-0.314999999999838,1.5165456871123));
#804=CARTESIAN_POINT('',(-0.126461756220516,-0.314999999999879,1.51417417547776));
#805=CARTESIAN_POINT('',(-0.131745682467166,-0.314999999999962,1.51253374101572));
#806=CARTESIAN_POINT('',(-0.141972342695954,-0.314999999999946,1.50839201015679));
#807=CARTESIAN_POINT('',(-0.146914619408429,-0.314999999999846,1.50588958585433));
#808=CARTESIAN_POINT('',(-0.156316198416724,-0.31499999999987,1.50010084312721));
#809=CARTESIAN_POINT('',(-0.160775475617129,-0.314999999999993,1.49681448399968));
#810=CARTESIAN_POINT('',(-0.169149344795455,-0.315000000000006,1.48950701612493));
#811=CARTESIAN_POINT('',(-0.173055963184205,-0.314999999999892,1.48547677468613));
#812=CARTESIAN_POINT('',(-0.180153505137685,-0.314999999999824,1.47682916479866));
#813=CARTESIAN_POINT('',(-0.183344359016229,-0.31499999999987,1.47221173925079));
#814=CARTESIAN_POINT('',(-0.188989783698884,-0.314999999999878,1.46242009090622));
#815=CARTESIAN_POINT('',(-0.191427924610063,-0.314999999999839,1.4572363963016));
#816=CARTESIAN_POINT('',(-0.1954191292293,-0.314999999999877,1.44653885306707));
#817=CARTESIAN_POINT('',(-0.196972093318111,-0.314999999999956,1.44102496735404));
#818=CARTESIAN_POINT('',(-0.199179807799885,-0.314999999999946,1.42970323761826));
#819=CARTESIAN_POINT('',(-0.199815595994473,-0.314999999999854,1.42389169205337));
#820=CARTESIAN_POINT('',(-0.200115101511228,-0.314999999999862,1.41224344172892));
#821=CARTESIAN_POINT('',(-0.19977873599552,-0.314999999999963,1.40640673486766));
#822=CARTESIAN_POINT('',(-0.198133607503213,-0.31499999999998,1.39480068307578));
#823=CARTESIAN_POINT('',(-0.196813314168126,-0.314999999999894,1.38903296767051));
#824=CARTESIAN_POINT('',(-0.193220488605554,-0.314999999999822,1.37780174059748));
#825=CARTESIAN_POINT('',(-0.190947940457849,-0.314999999999835,1.37233823401737));
#826=CARTESIAN_POINT('',(-0.185516671106973,-0.314999999999831,1.36189161862719));
#827=CARTESIAN_POINT('',(-0.182360667496542,-0.314999999999813,1.35690709859538));
#828=CARTESIAN_POINT('',(-0.175241790237766,-0.314999999999903,1.34755152247131));
#829=CARTESIAN_POINT('',(-0.171278986342007,-0.31500000000001,1.34318041340126));
#830=CARTESIAN_POINT('',(-0.162735147956348,-0.314999999999982,1.33526598682601));
#831=CARTESIAN_POINT('',(-0.158166981206588,-0.31499999999985,1.33170878664274));
#832=CARTESIAN_POINT('',(-0.148485080552246,-0.314999999999866,1.32543666262582));
#833=CARTESIAN_POINT('',(-0.143371456367232,-0.315000000000013,1.32272156982878));
#834=CARTESIAN_POINT('',(-0.13288945153804,-0.315,1.31828629427323));
#835=CARTESIAN_POINT('',(-0.127531422951835,-0.314999999999848,1.31654163694066));
#836=CARTESIAN_POINT('',(-0.116593920919699,-0.314999999999869,1.31399771913733));
#837=CARTESIAN_POINT('',(-0.111014420103207,-0.315000000000042,1.31319857589588));
#838=CARTESIAN_POINT('',(-0.0999156825502578,-0.315000000000054,1.31258015419147));
#839=CARTESIAN_POINT('',(-0.094397511905095,-0.314999999999899,1.31274136977445));
#840=CARTESIAN_POINT('',(-0.0834726493704285,-0.314999999999818,1.31399295613573));
#841=CARTESIAN_POINT('',(-0.0780658206348748,-0.31499999999989,1.31508210677419));
#842=CARTESIAN_POINT('',(-0.0697249401879211,-0.314999999999887,1.31750648755642));
#843=CARTESIAN_POINT('',(-0.0667024220631993,-0.314999999999861,1.31854830065978));
#844=CARTESIAN_POINT('',(-0.06077290606736,-0.314999999999856,1.32092033268639));
#845=CARTESIAN_POINT('',(-0.0578659055273917,-0.314999999999878,1.32225054494205));
#846=CARTESIAN_POINT('',(-0.0550288065375021,-0.314999999999881,1.32371909110253));
#847=B_SPLINE_CURVE_WITH_KNOTS('',3,(#769,#770,#771,#772,#773,#774,#775,#776,#777,#778,#779,
#780,#781,#782,#783,#784,#785,#786,#787,#788,#789,#790,#791,#792,#793,#794,#795,#796,#797,#798,
#799,#800,#801,#802,#803,#804,#805,#806,#807,#808,#809,#810,#811,#812,#813,#814,#815,#816,#817,
#818,#819,#820,#821,#822,#823,#824,#825,#826,#827,#828,#829,#830,#831,#832,#833,#834,#835,#836,
#837,#838,#839,#840,#841,#842,#843,#844,#845,#846),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.0170096277634144,
0.0340447979512979,0.0510527863378031,0.0680565674226079,0.0853863307544822,0.102718716646996,
0.120347290989466,0.137976446084015,0.15563476433532,0.173292075321473,0.19071749666865,
0.208140931811476,0.22519527948247,0.242247538191427,0.258957582367797,0.275666302187987,
0.292186638844828,0.308706760278301,0.325248580768411,0.341791260317194,0.358552472039451,
0.375315314910529,0.392421701981059,0.409530013852441,0.426987199308104,0.444445872346218,
0.462112420566851,0.479779264156506,0.497392349019654,0.515003911775113,0.532287952841807,
0.549568523731146,0.566390831897543,0.583215225554966,0.599699078106931,0.616161289468114,
0.625738667050705,0.63531582323435),.UNSPECIFIED.);
#848=EDGE_CURVE('E56',#766,#658,#847,.T.);
#849=ORIENTED_EDGE('',*,*,#848,.T.);
#850=EDGE_LOOP('',(#676,#759,#768,#849));
#851=FACE_BOUND('',#850,.T.);
#852=ADVANCED_FACE('F110',(#851),#675,.T.);
#853=CARTESIAN_POINT('',(-34.9250000000016,0.,0.));
#854=DIRECTION('',(-1.00000000000003,0.,0.));
#855=DIRECTION('',(0.,0.,1.00000000000001));
#856=AXIS2_PLACEMENT_3D('',#853,#854,#855);
#857=CYLINDRICAL_SURFACE('',#856,1.35);
#858=DIRECTION('',(-1.00000000000003,0.,0.));
#859=VECTOR('',#858,1.);
#860=CARTESIAN_POINT('',(-34.9250000000019,0.314999999999989,1.31273569312305));
#861=LINE('',#860,#859);
#862=EDGE_CURVE('E11',#30,#757,#861,.F.);
#863=ORIENTED_EDGE('',*,*,#862,.F.);
#864=ORIENTED_EDGE('',*,*,#33,.T.);
#865=DIRECTION('',(-1.00000000000003,0.,0.));
#866=VECTOR('',#865,1.);
#867=CARTESIAN_POINT('',(-34.9250000000017,-0.314999999999985,1.31273569312335));
#868=LINE('',#867,#866);
#869=EDGE_CURVE('E42',#766,#32,#868,.T.);
#870=ORIENTED_EDGE('',*,*,#869,.F.);
#871=ORIENTED_EDGE('',*,*,#767,.F.);
#872=EDGE_LOOP('',(#863,#864,#870,#871));
#873=FACE_BOUND('',#872,.T.);
#874=ADVANCED_FACE('F146',(#873),#857,.F.);
#875=CARTESIAN_POINT('',(-0.700000000000423,-0.314999999999857,-2.08166817117217E-13));
#876=DIRECTION('',(0.,1.00000000000002,0.));
#877=DIRECTION('',(0.,0.,1.00000000000001));
#878=AXIS2_PLACEMENT_3D('',#875,#876,#877);
#879=PLANE('',#878);
#880=ORIENTED_EDGE('',*,*,#419,.T.);
#881=ORIENTED_EDGE('',*,*,#451,.T.);
#882=ORIENTED_EDGE('',*,*,#633,.T.);
#883=ORIENTED_EDGE('',*,*,#665,.F.);
#884=ORIENTED_EDGE('',*,*,#848,.F.);
#885=ORIENTED_EDGE('',*,*,#869,.T.);
#886=ORIENTED_EDGE('',*,*,#206,.F.);
#887=ORIENTED_EDGE('',*,*,#237,.T.);
#888=EDGE_LOOP('',(#880,#881,#882,#883,#884,#885,#886,#887));
#889=FACE_BOUND('',#888,.T.);
#890=ADVANCED_FACE('F97',(#889),#879,.T.);
#891=CARTESIAN_POINT('',(-0.700000000000464,0.315000000000121,2.85599999999984));
#892=DIRECTION('',(0.,-1.00000000000002,0.));
#893=DIRECTION('',(0.,0.,-1.00000000000001));
#894=AXIS2_PLACEMENT_3D('',#891,#892,#893);
#895=PLANE('',#894);
#896=ORIENTED_EDGE('',*,*,#329,.T.);
#897=ORIENTED_EDGE('',*,*,#222,.T.);
#898=ORIENTED_EDGE('',*,*,#116,.F.);
#899=ORIENTED_EDGE('',*,*,#862,.T.);
#900=ORIENTED_EDGE('',*,*,#758,.F.);
#901=ORIENTED_EDGE('',*,*,#650,.F.);
#902=ORIENTED_EDGE('',*,*,#543,.T.);
#903=ORIENTED_EDGE('',*,*,#436,.T.);
#904=EDGE_LOOP('',(#896,#897,#898,#899,#900,#901,#902,#903));
#905=FACE_BOUND('',#904,.T.);
#906=ADVANCED_FACE('F159',(#905),#895,.T.);
#907=CLOSED_SHELL('',(#210,#242,#424,#456,#638,#670,#852,#874,#890,#906));
#908=MANIFOLD_SOLID_BREP('B2',#907);
#909=ADVANCED_BREP_SHAPE_REPRESENTATION('',(#18,#908),#14);
#910=SHAPE_DEFINITION_REPRESENTATION(#9,#909);
ENDSEC;
END-ISO-10303-21;
